# Repository sebiik/axoloti-preenfm2

File README.md:

# axoloti-preenfm2

Nothing to see here, carry on.

Edit: Well actually I got Axoloti to work well on the PreenFM2 but it included some nasty hardware hacking and a new, proper DAC chip plugged onto the P405 board, all of which is why I won't release any further info on this project.

## EAGLE design preenfm2-master/hardware/VanDaalElectronics/CV_converter_v06.brd

Parts:
5VOUT: PINHD-1X2; 1X02
5V_SELECT: MA03-1
C1, C3, C5, C9, C11: 100n; C025-025X050
C2: 330n; C025-025X050
C4, C6, C10: 220uF; E2,5-7
CV_IN: PINHD-1X6; 1X06
D2, D3, D4, D5, D6, D7, D8, D9: SCHOTTKY-DIODEDO35-7; DO35-7
D10, D11, D12, D13: DIODE-D-7.5; D-7.5
ENTER_BOOT: PINHD-1X2; 1X02
EURORACK_PWR: 057-016-1
IC1, IC4: DIL40
IC2: OPAMP; DIP08
IC3: 7805; TO-220-ALT
R1: 10k; RTRIM64W
R2, R3, R4, R5, R8, R9, R10, R11, R16: 10k; 0207/7
R6, R12: 6.8K; 0207/7
R7, R13: 3K; 0207/7
R14: 3.3k; 0207/7
R15: 4.7k; 0207/7
SWD_DEBUG: MA05-1
USB_FRONT: PINHD-1X4; 1X04

Connections:
3: IC1.3, IC4.3
3.3V: D2.C, D4.C, D6.C, D8.C, ENTER_BOOT.1, IC1.1, IC1.16, IC4.1, IC4.16, SWD_DEBUG.1
5: IC1.5, IC4.5
6: IC1.6, IC4.6
7: IC1.7, IC4.7
9: IC1.9, IC4.9
10: IC1.10, IC4.10
11: IC1.11, IC4.11
12: IC1.12, IC4.12
13: IC1.13, IC4.13
14: IC1.14, IC4.14
15: IC1.15, IC4.15
18: IC1.18, IC4.18
19: IC1.19, IC4.19
20: IC1.20, IC4.20
26: IC1.26, IC4.26
27: IC1.27, IC4.27
28: IC1.28, IC4.28
29: IC1.29, IC4.29
30: IC1.30, IC4.30
31: IC1.31, IC4.31
32: IC1.32, IC4.32
33: IC1.33, IC4.33
34: IC1.34, IC4.34
35: IC1.35, IC4.35
36: IC1.36, IC4.36
37: IC1.37, IC4.37
40: IC1.40, IC4.40
+5V: 5VOUT.2, 5V_SELECT.2, R3.1, R9.1
+5V_PSU: 5V_SELECT.1, EURORACK_PWR.11, EURORACK_PWR.12
+5V_REGU: 5V_SELECT.3, C3.1, C4.+, D10.A, IC3.OUT
+12V: C5.2, C6.+, C9.1, D11.A, D13.C, IC2.8 (V+)
-12V: C1.1, C10.-, C11.1, D12.A, IC2.4 (V-)
CV1_IN: CV_IN.1, R16.2
CV1_OUT: D8.A, D9.C, IC1.22, IC4.22, R16.1
CV2_IN: CV_IN.2, R1.3 (E), R15.2
CV2_OUT: D6.A, D7.C, IC1.23, IC4.23, R1.2 (S), R14.2, R15.1
CV3_IN: CV_IN.3, R8.1
CV3_OUT: D4.A, D5.C, IC1.24, IC4.24, R12.1, R13.2
CV4_IN: CV_IN.4, R2.1
CV4_OUT: D2.A, D3.C, IC1.25, IC4.25, R6.1, R7.2
DATA+: IC1.39, IC4.39, USB_FRONT.2
DATA-: IC1.38, IC4.38, USB_FRONT.1
GND: 5VOUT.1, C1.2, C2.2, C3.2, C4.-, C5.1, C6.-, C9.2, C10.+, C11.2, CV_IN.5, CV_IN.6, D3.A, D5.A, D7.A, D9.A, EURORACK_PWR.3, EURORACK_PWR.4, EURORACK_PWR.5, EURORACK_PWR.6, EURORACK_PWR.7, EURORACK_PWR.8, IC1.2, IC3.GND, IC4.2, R1.1 (A), R5.1, R7.1, R11.1, R13.1, R14.1, SWD_DEBUG.3, USB_FRONT.3, USB_FRONT.4
LODR: ENTER_BOOT.2, IC1.17, IC4.17
unnamed: IC2.1 (OUT), R4.2, R6.2
unnamed: IC2.3 (+IN), R2.2, R3.2
unnamed: C2.1, D10.C, D11.C, IC3.IN
unnamed: IC2.2 (-IN), R4.1, R5.2
unnamed: IC2.6 (-IN), R10.1, R11.2
unnamed: IC2.7 (OUT), R10.2, R12.2
unnamed: IC2.5 (+IN), R8.2, R9.2
unnamed: D12.C, EURORACK_PWR.1, EURORACK_PWR.2
unnamed: D13.A, EURORACK_PWR.9, EURORACK_PWR.10
RESET: IC1.21, IC4.21, SWD_DEBUG.5
SWD_CLK: IC1.8, IC4.8, SWD_DEBUG.2
SWD_IO: IC1.4, IC4.4, SWD_DEBUG.4

Board: 2 copper layers, 100.0 x 50.0 mm, 48 parts (0 on the bottom side), 57 nets.

File preenfm2-master/hardware/VanDaalElectronics/partslist.txt:

Partlist

Exported from CV_converter_v06.sch at 2019-04-16 13:13

EAGLE Version 9.3.0 Copyright (c) 1988-2019 Autodesk, Inc.

Assembly variant: 

Part         Value          Device               Package      Library           Sheet

5VOUT                       PINHD-1X2            1X02         pinhead           1
5V_SELECT                   MA03-1               MA03-1       con-lstb          1
C1           100n           C-EU025-025X050      C025-025X050 resistor          1
C2           330n           C-EU025-025X050      C025-025X050 resistor          1
C3           100n           C-EU025-025X050      C025-025X050 resistor          1
C4           220uF          CPOL-EUE2.5-7        E2,5-7       resistor          1
C5           100n           C-EU025-025X050      C025-025X050 resistor          1
C6           220uF          CPOL-EUE2.5-7        E2,5-7       resistor          1
C9           100n           C-EU025-025X050      C025-025X050 resistor          1
C10          220uF          CPOL-EUE2.5-7        E2,5-7       resistor          1
C11          100n           C-EU025-025X050      C025-025X050 resistor          1
CV_IN                       PINHD-1X6            1X06         pinhead           1
D2                          SCHOTTKY-DIODEDO35-7 DO35-7       diode             1
D3                          SCHOTTKY-DIODEDO35-7 DO35-7       diode             1
D4                          SCHOTTKY-DIODEDO35-7 DO35-7       diode             1
D5                          SCHOTTKY-DIODEDO35-7 DO35-7       diode             1
D6                          SCHOTTKY-DIODEDO35-7 DO35-7       diode             1
D7                          SCHOTTKY-DIODEDO35-7 DO35-7       diode             1
D8                          SCHOTTKY-DIODEDO35-7 DO35-7       diode             1
D9                          SCHOTTKY-DIODEDO35-7 DO35-7       diode             1
D10                         DIODE-D-7.5          D-7.5        diode             1
D11                         DIODE-D-7.5          D-7.5        diode             1
D12                         DIODE-D-7.5          D-7.5        diode             1
D13                         DIODE-D-7.5          D-7.5        diode             1
ENTER_BOOT                  PINHD-1X2            1X02         pinhead           1
EURORACK_PWR 057-016-1      057-016-1            057-016-1    con-panduit       1
IC1                         DIL40                DIL40        ic-package        1
IC2          OPAMP          OPAMP-DUALDIP        DIP08        SparkFun-AnalogIC 1
IC3          7805           V_REG_78XX-TO-220    TO-220-ALT   SparkFun-PowerIC  1
IC4                         DIL40                DIL40        ic-package        1
R1           10k            R-TRIMM64W           RTRIM64W     resistor          1
R2           10k            R-EU_0207/7          0207/7       rcl               1
R3           10k            R-EU_0207/7          0207/7       rcl               1
R4           10k            R-EU_0207/7          0207/7       rcl               1
R5           10k            R-EU_0207/7          0207/7       rcl               1
R6           6.8K           R-EU_0207/7          0207/7       rcl               1
R7           3K             R-EU_0207/7          0207/7       rcl               1
R8           10k            R-EU_0207/7          0207/7       rcl               1
R9           10k            R-EU_0207/7          0207/7       rcl               1
R10          10k            R-EU_0207/7          0207/7       rcl               1
R11          10k            R-EU_0207/7          0207/7       rcl               1
R12          6.8K           R-EU_0207/7          0207/7       rcl               1
R13          3K             R-EU_0207/7          0207/7       rcl               1
R14          3.3k           R-EU_0207/7          0207/7       rcl               1
R15          4.7k           R-EU_0207/7          0207/7       rcl               1
R16          10k            R-EU_0207/7          0207/7       rcl               1
SWD_DEBUG                   MA05-1               MA05-1       con-lstb          1
USB_FRONT                   PINHD-1X4            1X04         pinhead           1

## Commit log

2019-06-20 add BOARD_PREENFM2 option to defines
2019-06-21 commented out some pin assigments
2019-06-26 fork board_preenfm2.h file, include preenfm2 repository for reference
2019-07-02 design daughterboard for CS4354 DAC
2019-07-02 renamed kicad daughterboard 'noDIL'
2019-07-05 change I2S codec to CS4354 DAC
2019-10-04 cs4354 daughterboard fix, axo-preenfm2 analog input now working

Notices in the files:
parts and their libraries:
SparkFun-AnalogIC: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
